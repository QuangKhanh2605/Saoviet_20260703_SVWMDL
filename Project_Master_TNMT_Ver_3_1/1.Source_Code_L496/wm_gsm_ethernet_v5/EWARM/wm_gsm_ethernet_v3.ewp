# IAR project wm_gsm_ethernet_v3.ewp, settings and files
configuration wm_gsm_ethernet_v3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496VG ST STM32L496VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx; USER_VECT_TAB_ADDRESS; GLCD_CONTROLLER_ST7565R; GLCD_DEVICE_STM32L4XX
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\user_timer; ..\user_util; ..\user_trace; ..\user_component\user_mem\user_external_eeprom; ..\user_component\user_mem\user_internal_mem; ..\user_component\user_mem\user_external_flash; ..\user_component\user_mem; ..\user_component\user_sim\user_sim_module; ..\user_component\user_sim; ..\user_component\mqtt_lib\inc; ..\user_app\user_app_common; ..\user_app\user_at_serial; ..\user_app\user_app_sim; ..\user_app\user_app_wm; ..\user_component\user_lptim; ..\user_component\user_wm_digital; ..\user_glcd; ..\user_glcd\controllers; ..\user_glcd\fonts; ..\user_glcd\devices; ..\user_app\user_app_ethernet; ../FATFS/Target; ../FATFS/App; ../Middlewares/Third_Party/FatFs/src; ..\user_component\user_mem\user_sd_card; ..\HAL_Driver_LPTIM_Counter; ..\user_component\user_convert_variable; ..\user_component\user_sensor_digital; ..\user_component\user_ethernet_io\Application; ..\user_component\user_ethernet_io\Ethernet; ..\user_component\user_ethernet_io\Ethernet\W5500; ..\user_component\user_ethernet_io\Ethernet\W6100; ..\user_component\user_ethernet_io\Internet\DHCP; ..\user_component\user_ethernet_io\Internet\DHCP6; ..\user_component\user_ethernet_io\Internet\DNS; ..\user_component\user_ethernet_io\Internet\FTPClient
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SVTH_SVM_DLS_V5_1_5.bin
  ILINK.IlinkOutputFile: wm_gsm_ethernet_v3.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l496xx.s
  group Application/User/Core
    ../Core/Src/: adc.c dma.c gpio.c i2c.c iwdg.c lptim.c main.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c tim.c usart.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group user_app/user_app_comm
    ../user_app/user_app_common/: user_app_comm.c user_app_comm.h user_define.h user_log.h user_message.c user_message.h user_modem.c user_modem.h user_uart.c user_uart.h
  group user_app/user_app_ethernet
    ../user_app/user_app_ethernet/: user_app_ethernet.c user_app_ethernet.h
  group user_app/user_app_sim
    ../user_app/user_app_sim/: user_app_sim.c user_app_sim.h
  group user_app/user_app_wm
    ../user_app/user_app_wm/: button.c button.h lcd_display.c lcd_display.h user_app_modb_m.c user_app_modb_m.h user_app_modb_s.c user_app_modb_s.h user_app_sensor.c user_app_sensor.h user_app_wm.c user_app_wm.h user_rs485.c user_rs485.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_component/mqtt_lib
    ../user_component/mqtt_lib/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group user_component/user_convert_variable
    ../user_component/user_convert_variable/: user_convert_variable.c user_convert_variable.h
  group user_component/user_ethernet_io/Application
    ../user_component/user_ethernet_io/Application/: Application.h
  group user_component/user_ethernet_io/Ethernet
    ../user_component/user_ethernet_io/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group user_component/user_ethernet_io/Ethernet/W5500
    ../user_component/user_ethernet_io/Ethernet/W5500/: w5500.c w5500.h
  group user_component/user_ethernet_io/Ethernet/W6100
    ../user_component/user_ethernet_io/Ethernet/W6100/: w6100.c w6100.h
  group user_component/user_ethernet_io/Internet/DHCP
    ../user_component/user_ethernet_io/Internet/DHCP/: dhcp.c dhcp.h
  group user_component/user_ethernet_io/Internet/DHCP6
    ../user_component/user_ethernet_io/Internet/DHCP6/: dhcpv6.c dhcpv6.h
  group user_component/user_ethernet_io/Internet/DNS
    ../user_component/user_ethernet_io/Internet/DNS/: dns.c dns.h
  group user_component/user_lptim
    ../user_component/user_lptim/: user_lptim.c user_lptim.h
  group user_component/user_memory
    ../user_component/user_mem/: user_mem.c user_mem.h user_mem_comm.c user_mem_comm.h
  group user_component/user_memory/user_external_eeprom
    ../user_component/user_mem/user_external_eeprom/: cat24mxx.c cat24mxx.h
  group user_component/user_memory/user_external_flash
    ../user_component/user_mem/user_external_flash/: S25FL216K.c S25FL216K.h
  group user_component/user_memory/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_component/user_memory/user_sd_card
    ../user_component/user_mem/user_sd_card/: sd_benchmark.c sd_benchmark.h sd_diskio_spi.c sd_diskio_spi.h sd_functions.c sd_functions.h sd_spi.c sd_spi.h user_sd.c user_sd.h
  group user_component/user_sensor_digital
    ../user_component/user_sensor_digital/: user_sensor_daruifuno.c user_sensor_daruifuno.h user_sensor_saoviet.c user_sensor_saoviet.h user_sensor_xylem.c user_sensor_xylem.h
  group user_component/user_sim
    ../user_component/user_sim/: user_sim.c user_sim.h user_sim_common.c user_sim_common.h user_sim_config.h
  group user_component/user_sim/module
    ../user_component/user_sim/user_sim_module/: user_ec200u.c user_ec200u.h user_l506.c user_l506.h user_l511.c user_l511.h
  group user_component/user_wm_digital
    ../user_component/user_wm_digital/: level_S_YW_01B.c level_S_YW_01B.h level_SUP_PX261_B.c level_SUP_PX261_B.h level_ultrasonic.c level_ultrasonic.h siemen_mag6000.c siemen_mag6000.h siemen_mag8000.c siemen_mag8000.h user_wm_digital.c user_wm_digital.h wm_mong_cai.c wm_mong_cai.h wm_mt100.c wm_mt100.h wm_sence.c wm_sence.h woteck_ultrasonic.c woteck_ultrasonic.h woteck_wm.c woteck_wm.h
  group user_driver_stm32_lptim
    ../HAL_Driver_LPTIM_Counter/: stm32l4xx_hal_lptim.c stm32l4xx_hal_lptim.h
  group user_glcd
    ../user_glcd/: glcd.c glcd.h glcd_controllers.h glcd_graphics.h glcd_graphs.h glcd_text.h glcd_text_tiny.h graphics.c graphs.c text.c text_tiny.c unit_tests.c unit_tests.h
  group user_glcd/controller
    ../user_glcd/controllers/: NT75451.c NT75451.h PCD8544.c PCD8544.h ST7565R.c ST7565R.h
  group user_glcd/device
    ../user_glcd/devices/: STM32F0xx.c STM32F0xx.h STM32F10x.c STM32F10x.h STM32F4.c STM32F4.h STM32L4.c STM32L4.h
  group user_glcd/font
    ../user_glcd/fonts/: Bebas_Neue18x36_Numbers.h Bebas_Neue20x36_Bold_Numbers.h Earthbound_12x19_48to57.h font5x7.h Liberation_Sans11x14_Numbers.h Liberation_Sans15x21_Numbers.h Liberation_Sans17x17_Alpha.h Liberation_Sans20x28_Numbers.h Liberation_Sans27x36_Numbers.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_trace
    ../user_trace/: user_adv_trace.c user_adv_trace.h
  group user_util
    ../user_util/: event_driven.c event_driven.h onchipflash.c onchipflash.h queue_p.c queue_p.h user_adc.c user_adc.h user_json.c user_json.h user_lpm.c user_lpm.h user_modbus_rtu.c user_modbus_rtu.h user_obis_sv.c user_obis_sv.h user_string.c user_string.h user_time.c user_time.h user_tiny_vsnprintf.c user_tiny_vsnprintf.h user_util.c user_util.h
